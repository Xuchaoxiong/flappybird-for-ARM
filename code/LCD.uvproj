# Keil uVision project LCD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LCD
  c flags: Optim=1
  c define: TARGET_IS_BLIZZARD_RA1
  c misc: -c99
  c include: E:\keil\libraries
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: LCD_Matrix.h LCDDriver.c LCDDriver.h Startup.s main.c lcda.h
    E:/keil/libraries/driverlib/rvmdk/: driverlib.lib
    ../lcddriver/: font.c font.h screen.c screen.h
